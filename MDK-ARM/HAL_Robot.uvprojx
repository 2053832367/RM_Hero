# Keil uVision project HAL_Robot.uvprojx, settings and files
target HAL_Robot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: HAL_Robot +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_PWR_LDO_SUPPLY
  c misc: --gnu;-diag_suppress=2903,1,1035;--cpp11;-diag_suppress=3337
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Task/Inc;../App/Inc;../Device/Inc;../ModuleDrivers/Inc;../Protocol/Inc;../Algorithm/Inc;../Middlewares/DSP/Include;../Middlewares/DSP;../Drivers/CMSIS/Include;../new_motor_set;../pack
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Task
    ../Task/: Message_Task.cpp Chassis_Task.cpp Correspond_Task.cpp Gimbal_Task.cpp Guard_Task.cpp RTOSsystem_task.cpp UIDraw_Task.cpp
  group App
    ../App/: app_motor.cpp app_serial.cpp app_preference.cpp app_rgb.cpp app_oled.cpp app_vofa.cpp CANDrive.c
  group Device
    ../Device/: dev_can.cpp dev_serial.cpp dev_system.cpp
  group ModuleDrivers
    ../ModuleDrivers/: drivers_buffer.cpp drivers_dma.cpp drivers_statistic.cpp bsp_dwt.cpp
  group Protocol
    ../Protocol/: protocol_crc.cpp protocol_dbus.cpp protocol_judgement.cpp protocol_ui.cpp
  group Algorithm
    ../Algorithm/: algorithm_kalman.cpp algorithm_LADRC.cpp algorithm_pid.cpp algorithm_user_lib.cpp chassis_power_control.cpp algorithm_Solve_Trajectory.c
  group Middlewares/DSP
    ../Middlewares/DSP/: arm_cortexM4lf_math.lib
  group pack
    ../pack/: priority_ui.cpp
software components: CMSIS:CORE 6.1.0
